<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Bootloader\EWARM\Bootloader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TKX_ThreadX.ewp</path>
    </project>
    <batchBuild />
</workspace>
