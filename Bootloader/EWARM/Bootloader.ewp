# IAR project Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: Bootloader.out
  group Comm
    ../Comm/Src/: comm_uart.c
    ../Comm/Inc/: comm_uart.h
  group Core/Inc
    ../Core/Inc/: boot_config.h boot_crc.h boot_jump.h boot_main.h boot_selftest.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Core/Src
    ../Core/Src/: boot_crc.c boot_jump.c boot_main.c boot_selftest.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
  group Factory
    ../Factory/Src/: factory_calibration.c factory_mode.c
    ../Factory/Inc/: factory_calibration.h factory_mode.h
  group Startup
    ../../EWARM/: startup_stm32f407xx.s
  group Storage
    ../Storage/Src/: storage_flash.c
    ../Storage/Inc/: storage_flash.h
